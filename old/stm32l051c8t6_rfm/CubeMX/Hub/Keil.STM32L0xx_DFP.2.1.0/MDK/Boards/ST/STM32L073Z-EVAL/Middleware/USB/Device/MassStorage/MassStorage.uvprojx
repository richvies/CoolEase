# Keil uVision project MassStorage.uvprojx, settings and files
target Debug (6140000::V6.14::ARMCLANG)
  device: STM32L073VZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.2-dev6
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MassStorage
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT6: RAM 0x20004800 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4800
  group Source
    ./: MassStorage.c USBD_User_MSC_0.c
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L073VZTx/STCubeGenerated/Src/: main.c stm32l0xx_it.c
    ./RTE/Device/STM32L073VZTx/STCubeGenerated/Inc/: stm32l0xx_it.h
target Release (6140000::V6.14::ARMCLANG)
  device: STM32L073VZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.2-dev6
  cpu: as above
  output: MassStorage
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, Compiler:I/O:File 1.2.0, File System:CORE 6.13.6, File System:Drive:Memory Card 6.13.6, USB:CORE 6.14.0, USB:CORE 6.14.0, USB:Device 6.14.0, USB:Device:MSC 6.14.0, Device:STM32Cube HAL 1.10.2, CMSIS Driver:SPI 1.0.0, CMSIS Driver:USB Device 1.3.0
